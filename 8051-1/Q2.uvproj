# Keil uVision project Q2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT85C51SND3 Atmel
  cpu: IROM(0-0xFFFF) IRAM(0-0xFF) XRAM(0-0x7FF) CLOCK(24000000) MODP2
  output: Q2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Q2.ASM
